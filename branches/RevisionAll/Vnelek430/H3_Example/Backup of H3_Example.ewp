# IAR project Backup of H3_Example.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5510 MSP430F5510
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; USB_config; F5xx_F6xx_Core_Lib; Programmer; ProgrammerX
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5510.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: $PROJ_DIR$; USB_config; F5xx_F6xx_Core_Lib
  ICC430.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5133.xcl
  group (top)
    ./: main.c main.h usbConstructs.c usbConstructs.h usbEventHandling.c
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group Programmer
    Programmer/: Config430.h Devices430.c Devices430.h FlashErase.c FlashWrite.c JTAGfunc430.c JTAGfunc430.h LowLevelFunc430.c LowLevelFunc430.h Replicator430.h Target_Code.h
  group ProgrammerX
    ProgrammerX/: Config430X.h Devices430X.c Devices430X.h JTAGfunc430X.c JTAGfunc430X.h LowLevelFunc430X.c LowLevelFunc430X.h Replicator430X.h Target_Code.h Target_Code_IAR.s43
  group USB_API/USB_CDC_API
    USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
  group USB_API/USB_HID_API
    USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group USB_API/USB_MSC_API
    USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group USB_API/USB_PHDC_API
    USB_API/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group USB_config
    USB_config/: descriptors.c descriptors.h UsbIsr.c
