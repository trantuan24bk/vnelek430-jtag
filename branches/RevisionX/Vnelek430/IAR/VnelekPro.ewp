# IAR project VnelekPro.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5510 MSP430F5510
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\main; ..\main\F5xx_F6xx_Core_Lib; ..\main\USB_API; ..\main\USB_API\USB_CDC_API; ..\main\USB_API\USB_Common; ..\main\USB_API\USB_HID_API; ..\main\USB_API\USB_MSC_API; ..\main\USB_API\USB_PHDC_API; ..\main\USB_App; ..\main\USB_config; ..\main\Programmer
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5510.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../main/: main.c main.h
  group F5xx_F6xx_Core_Lib
    ../main/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h hal_macros.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c hal_UCS.h
  group Programmer
    ../main/Programmer/: Config430X.h Devices430X.c Devices430X.h JTAGfunc430X.c JTAGfunc430X.h LowLevelFunc430X.c LowLevelFunc430X.h Replicator430X.h Target_Code.h Target_Code_IAR.s43
  group USB_API
    ../main/USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
    ../main/USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_App
    ../main/USB_App/: usbConstructs.c usbConstructs.h usbEventHandling.c
  group USB_config
    ../main/USB_config/: descriptors.c descriptors.h UsbIsr.c
